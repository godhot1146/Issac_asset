Commit message: Update fryer basket and worktable assets

File: isaac_assets/urdf/worktable2/worktable2.urdf (robot description, URDF)
Before this commit: robot worktable2, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.90 0.04 0.94; collision box size=0.90 0.56 0.84
